# Keil uVision project Template.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ./Library/Algorithm;./Library/CMSIS;./Library/Component/Clock;./Library/Component/CRTP;./Library/Component/FatFs;./Library/Component/OLEDGLib;./Library/Component/Shell;./Library/Hardware/AHT10;./Library/Hardware/Buzzer;./Library/Hardware/DHT11;./Library/Hardware/Encoder;./Library/Hardware/ESP8266;./Library/Hardware/HCRS04;./Library/Hardware/HX711;./Library/Hardware/InkScreen;./Library/Hardware/KEY;./Library/Hardware/LED;./Library/Hardware/MatrixKey;./Library/Hardware/Motor;./Library/Hardware/MPU6050;./Library/Hardware/MPU6050/eMPL;./Library/Hardware/Nixie;./Library/Hardware/OLED;./Library/Hardware/PS2;./Library/Hardware/Servo;./Library/Hardware/W25QXX;./Library/StartUp;./Library/STM32F1xx_HAL_Driver/Inc;./Library/STM32F1xx_HAL_Driver/Inc/Legacy;./Library/System/AD;./Library/System/BKP;./Library/System/BootLoader;./Library/System/CAN;./Library/System/delay;./Library/System/Flash;./Library/System/I2C;./Library/System/lowpower;./Library/System/RTC;./Library/System/SPI;./Library/System/sys;./Library/System/TIM1;./Library/System/TIM2;./Library/System/TIM3;./Library/System/TIM4;./Library/System/USART;./Library/System/WDG;./User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./Library/CMSIS/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group StartUp
    ./Library/StartUp/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Hardware
    ./Library/Hardware/KEY/: Key.c Key.h
    ./Library/System/delay/: delay.c delay.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
